# Autodesk Inventor part: 8MR191-1-PHYTRON
## iProperties
Created: 2007-08
Part Number: 8MR191-1-PHYTRON
Document SubType Name: Modeling
Designer: Darius
Author: Darius
## Feature names
1. Base1
